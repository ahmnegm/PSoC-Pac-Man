# Keil uVision project vga_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5268AXI-LP047 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: vga_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h VERT.c VERT.h VERT_PM.c VGA_aliases.h VGA.c VGA.h HORIZ.c HORIZ.h HORIZ_PM.c VSYNC.c VSYNC.h VSYNC_PM.c cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h VGA_CLK.c VGA_CLK.h HSYNC.c HSYNC.h HSYNC_PM.c DMA_dma.c DMA_dma.h PIXEL.c PIXEL.h NEWLINE.c NEWLINE.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c UART_IntClock.c UART_IntClock.h HSYNC_OUT_aliases.h HSYNC_OUT.c HSYNC_OUT.h VSYNC_OUT_aliases.h VSYNC_OUT.c VSYNC_OUT.h
target Release (ARM-GNU)
  device: CY8C5268AXI-LP047 Cypress
  cpu: as above
  output: vga_PSoC5lib (library)
